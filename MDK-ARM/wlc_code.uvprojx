# Keil uVision project wlc_code.uvprojx, settings and files
target wlc_code (6240000::V6.24::ARMCLANG)
  device: APM32F103CB Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wlc_code +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F10X_HD
  c include: ..\Drivers\APM32F10x_StdPeriphDriver\inc;..\Drivers\CMSIS\Include;..\Drivers\Device\Geehy\APM32F10x\Include;..\Core\Inc;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM3;..\Bsp\inc;..\User\WLC_driver\inc;..\User\WLC_server\wlc_communications_physical\inc;..\User\WLC_server\wlc_power_bridge\inc;..\User\WLC_server\wlc_timer\inc;..\User\WLC_app\inc;..\User\common\type;..\Lib;..\Components\ringbuffer
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s
  group Peripherals
    ../Drivers/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group CMSIS
    ../Drivers/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
  group Core
    ../Core/Src/: main.c apm32f10x_int.c freertos_task.c
  group Bsp
    ../Bsp/inc/: bsp_platform.h
    ../Bsp/src/: bsp_uart.c bsp_pwm.c bsp_adc.c bsp_eeprom.c bsp_qc.c bsp_irq.c bsp_timer.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM3/: port.c
  group common\type
    ../User/common/type/: wlc_platform_types.h wlc_types.h
  group WLC_driver
    ../User/WLC_driver/src/: wlc_lib.c
    ../User/WLC_driver/inc/: wlc_lib_interal_functions.h
  group WLC_server/wlc_phy
    ../User/WLC_server/wlc_communications_physical/src/: wlc_physical.c
  group WLC_server/wlc_bridge
    ../User/WLC_server/wlc_power_bridge/src/: wlc_power_bridge.c
  group WLC_server/wlc_timer
    ../User/WLC_server/wlc_timer/src/: wlc_timer.c
  group WLC_app
    ../User/WLC_app/src/: Qi_Response.c Qi_Ping.c Qi_Power_Delivery.c wlc_app.c Qi_IdConfig.c Qi_Negotiation.c Qi_Power_Transfer.c
  group Lib
    ../Lib/: Tomato_wlc.h Tomato_wlc.lib
  group Components\ringbuffer
    ../Components/ringbuffer/: ring_buffer.c
